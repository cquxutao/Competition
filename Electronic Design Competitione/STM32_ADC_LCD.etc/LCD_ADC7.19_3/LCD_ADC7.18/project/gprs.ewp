# IAR project gprs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\USER\inc\; ..\UCOS\inc\; ..\STM32_LIB\inc\; ..\STM32_LIB\config\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gprs.bin
  ILINK.IlinkOutputFile: gprs.out
  ILINK.IlinkIcfFile: ..\USER\linkerCofig\STM32_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group stm32_lib/config
    ../STM32_LIB/config/: stm32f10x_conf.h
  group stm32_lib/inc
    ../STM32_LIB/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group stm32_lib/lib
    ../STM32_LIB/lib/: stm32_2.0.3_lib.a
  group stm32_lib/startup
    ../STM32_LIB/startup/: cortexm3_macro.s stm32f10x_vector.c
  group user/inc
    ../STM32_LIB/inc/: 12864.h
    ../USER/inc/: BoardInit.h Hex.h I2C.h ili9320.h includes.h main.h module.h PS2.h stm32f10x_it.h type.h
  group user/src
    ../USER/src/: 12864.c BoardInit.c Hex.c I2C.c ili9320.c main.c module.c PS2.c stm32f10x_it.c
