# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1
  c include: .\Source\User\Main;.\Source\CMSIS\Core\CM3;.\Source\STM32F10x_StdPeriph_Driver\inc;.\Source\User\Usart
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./Source/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group Main
    ./Source/User/Main/: main.c stm32f10x_it.c stm32f10x_conf.h usually.h
    ./Source/User/Usart/: usart.c
    ./Source/User/lcd12864/: lcd12864.c
    ./Source/User/adc/: adc.c adc.h
    ./Source/User/tim/: tim.c stm32f10x_tim.c stm32f10x_tim.h tim.h
    ./Source/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dma.c
    ./Source/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_adc.h stm32f10x_dma.h
  group StdPeriph_Driver
    ./Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Readme
    ./Source/User/Doc/: Readme.c
